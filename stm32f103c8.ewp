# IAR project stm32f103c8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103c8.srec
  ILINK.IlinkOutputFile: stm32f103c8.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  group inc
    inc/: diskio.h ff.h ffconf.h integer.h sd.h stm32f0xx.h stm32f0xx_conf.h stm32f0xx_exti.h stm32f0xx_gpio.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_usart.h system_stm32f0xx.h xprintf.h
  group src
    src/: ff.c main.c sd.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c system_stm32f0xx.c xprintf.c
  group src/startup
    startup/: startup_stm32f051.s
